# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H743xx,USE_USB_FS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\FDCAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\DCMI;..\HARDWARE\OV5640;..\HARDWARE\USART2;..\HARDWARE\USART3;..\MALLOC;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\JPEGCODEC;..\HARDWARE\SPBLCD;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\HARDWARE\GSM;..\HARDWARE\ETHERNET;..\HARDWARE\SPDIF;..\FATFS\source;..\FATFS\exfuns;..\TEXT;..\PICTURE;..\APP;..\GUI;..\UCOSII\uC-LIB;..\UCOSII\uC-CPU;..\UCOSII\UCOS_BSP;..\UCOSII\uCOS-CONFIG;..\UCOSII\uCOS-II\Source;..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\USB\STM32_USB_Host_Library\Class\HID\Inc;..\USB\STM32_USB_Host_Library\Core\Inc;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\USB\USB_APP;..\USB\USB_HAL;..\AUDIOCODEC\ape;..\AUDIOCODEC\ape\apedec;..\AUDIOCODEC\flac;..\AUDIOCODEC\flac\flacdec;..\AUDIOCODEC\mp3;..\AUDIOCODEC\mp3\helix;..\AUDIOCODEC\wav;..\MJPEG;..\T9INPUT;..\ATKNCR;..\ATKFREC;..\ATKQR;..\QR_ENCODE;..\NES;..\SMS;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server_demo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source Group 1
    ./: startup_stm32h743xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/NAND/: nand.c ftl.c nandtester.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: myiic.c 24cxx.c
    ../HARDWARE/SAI/: sai.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/JPEGCODEC/: jpegcodec.c
    ../HARDWARE/SPBLCD/: spblcd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c gt9271.c touch.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/GSM/: gsm.c
    ../HARDWARE/MPU9250/: mpu9250.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/OV5640/: ov5640.c sccb.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ETHERNET/: lan8720.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
    ../HARDWARE/SPDIF/: spdif.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
    ../FATFS/source/: diskio.c ff.c ffsystem.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c hjpgd.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group APP
    ../APP/: common.c spb.c ebook.c calendar.c picviewer.c settings.c usbplay.c audioplay.c lyric.c videoplay.c notepad.c nesplay.c smsplay.c exeplay.c paint.c camera.c recorder.c calculator.c facereco.c qrplay.c netplay.c webcamera.c appplay.c appplay_remote.c appplay_spdifrx.c phoneplay.c wirelessplay.c gyroscope.c gradienter.c keyplay.c ledplay.c beepplay.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memlcd.c memo.c progressbar.c scrollbar.c window.c
  group UCOSII_BSP
    ../UCOSII/UCOS_BSP/: cpu_bsp.c bsp.c
  group UCOSII_CPU
    ../UCOSII/uC-CPU/: cpu_core.c
    ../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSII_LIB
    ../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSII_CORE
    ../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/uCOS-CONFIG/: app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group USB_CORE
    ../USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_HOST
    ../USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../USB/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_gamepad.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usbh_conf.c usbd_conf.c usbh_diskio.c usb_app.c usbd_storage.c usbd_desc.c
  group USB_PHY
    ../USB/USB_HAL/: stm32h7xx_ll_usb.c stm32h7xx_hal_hcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pcd.c
  group AUDIOCODEC_WAV
    ../AUDIOCODEC/wav/: wavplay.c
  group AUDIOCODEC_MP3
    ../AUDIOCODEC/mp3/: mp3play.c
    ../AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../AUDIOCODEC/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group AUDIOCODEC_FLAC
    ../AUDIOCODEC/flac/: flacplay.c
    ../AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
  group AUDIOCODEC_APE
    ../AUDIOCODEC/ape/: apeplay.c
    ../AUDIOCODEC/ape/apedec/: apedecoder.c entropy.c filter_16_11.c filter_32_10.c filter_64_11.c filter_256_13.c filter_1280_15.c parser.c predictor.c predictor-arm.S
  group MJPEG
    ../MJPEG/: avi.c mjpeg.c
  group T9INPUT
    ../T9INPUT/: t9input.c pyinput.c
  group ATKNCR
    ../ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group ATK_FREC
    ../ATKFREC/: atk_frec.c ATKFREC_DF.lib
  group ATKQR
    ../ATKQR/: atk_qrdecode.c ATK_QR_V1.4.lib
  group QR_ENCODE
    ../QR_ENCODE/: qr_encode.c
  group NES
    ../NES/: nes_main.c nes_apu.c nes_crc32.c nes_mapper.c nes_ppu.c 6502.s
  group SMS
    ../SMS/: sms_main.c sms_render.c sms_sn76496.c sms_vdp.c sms_z80a.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MPL
    ../HARDWARE/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9250/MPL/mpl/: libmpllib.lib
  group README
    ../: readme.txt
