# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H743xx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\FDCAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source Group 1
    ./: startup_stm32h743xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: myiic.c
    ../HARDWARE/MPU9250/: mpu9250.c
  group MPL
    ../HARDWARE/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9250/MPL/mpl/: libmpllib.lib
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
