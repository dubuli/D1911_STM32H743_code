# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32H743xx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\FDCAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\DCMI;..\HARDWARE\OV5640;..\HARDWARE\USART2;..\MALLOC;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\FATFS\source;..\FATFS\exfuns;..\TEXT;..\PICTURE;..\HARDWARE\JPEGCODEC;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\AUDIOCODEC\wav;..\HARDWARE\SPDIF;..\APP;..\MJPEG
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source Group 1
    ./: startup_stm32h743xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/NAND/: nand.c ftl.c nandtester.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: myiic.c
    ../HARDWARE/SAI/: sai.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/SPDIF/: spdif.c
    ../HARDWARE/JPEGCODEC/: jpegcodec.c
    ../HARDWARE/TIMER/: timer.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
    ../FATFS/source/: diskio.c ff.c ffsystem.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group AUDIOCODEC
    ../AUDIOCODEC/wav/: wavplay.c
  group APP
    ../APP/: audioplay.c videoplayer.c
  group MJPEG
    ../MJPEG/: avi.c mjpeg.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
